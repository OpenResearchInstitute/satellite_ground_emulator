<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>mpsk_stage3</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>arity</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>value</key><value>400000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>excess_bw</value></param>
<param><key>value</key><value>0.35</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq_offset</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>0,1,1,1</value></param>
<param><key>label</key><value>Frequency Offset</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-0.1</value></param>
<param><key>step</key><value>0.001</value></param>
<param><key>stop</key><value>0.1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nfilts</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>noise_volt</value></param>
<param><key>value</key><value>0.0001</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>label</key><value>Noise Voltage</value></param>
<param><key>orient</key><value>Qt.Vertical</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable_constellation_rect</key>
<param><key>id</key><value>qpsk</value></param>
<param><key>const_points</key><value>[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]</value></param>
<param><key>imag_sect</key><value>2</value></param>
<param><key>real_sect</key><value>2</value></param>
<param><key>rot_sym</key><value>4</value></param>
<param><key>sym_map</key><value>[0, 1, 2, 3]</value></param>
<param><key>w_imag_sect</key><value>1</value></param>
<param><key>w_real_sect</key><value>1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rf_freq_offset</value></param>
<param><key>value</key><value>0</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-1000</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>1000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rrc_taps</value></param>
<param><key>value</key><value>firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 45*nfilts)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>2.5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>taps</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>[1.0, 0.25-0.25j, 0.50 + 0.10j, -0.3 + 0.2j]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>taps</value></param>
<param><key>value</key><value>[1.0 + 0.0j, ]</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>time_offset</value></param>
<param><key>value</key><value>1.00</value></param>
<param><key>gui_hint</key><value>0,2,1,1</value></param>
<param><key>label</key><value>Timing Offset</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.999</value></param>
<param><key>step</key><value>0.0001</value></param>
<param><key>stop</key><value>1.001</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>timing_loop_bw</value></param>
<param><key>value</key><value>6.28/100.0</value></param>
<param><key>gui_hint</key><value>0,3,1,1</value></param>
<param><key>label</key><value>Time: BW</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>0.2</value></param>
<param><key>widget</key><value>slider</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>max</key><value>256</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_samps</key><value>10000</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>channels_channel_model</key>
<param><key>id</key><value>channels_channel_model_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>epsilon</key><value>time_offset</value></param>
<param><key>freq_offset</key><value>freq_offset</value></param>
<param><key>noise_voltage</key><value>noise_volt</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>taps</key><value>taps</value></param>
</block>
<block>
<key>digital_cma_equalizer_cc</key>
<param><key>id</key><value>digital_cma_equalizer_cc_0</value></param>
<param><key>mu</key><value>.01</value></param>
<param><key>modulus</key><value>4</value></param>
<param><key>num_taps</key><value>20</value></param>
<param><key>sps</key><value>1</value></param>
</block>
<block>
<key>digital_constellation_modulator</key>
<param><key>id</key><value>digital_constellation_modulator_0</value></param>
<param><key>constellation</key><value>qpsk</value></param>
<param><key>differential</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>excess_bw</key><value>excess_bw</value></param>
<param><key>samples_per_symbol</key><value>sps</value></param>
</block>
<block>
<key>digital_costas_loop_cc</key>
<param><key>id</key><value>digital_costas_loop_cc_0</value></param>
<param><key>w</key><value>3.14159*2/100</value></param>
<param><key>order</key><value>4</value></param>
</block>
<block>
<key>digital_pfb_clock_sync_xxx</key>
<param><key>id</key><value>digital_pfb_clock_sync_xxx_0</value></param>
<param><key>filter_size</key><value>nfilts</value></param>
<param><key>init_phase</key><value>nfilts/2</value></param>
<param><key>loop_bw</key><value>timing_loop_bw</value></param>
<param><key>max_dev</key><value>1.5</value></param>
<param><key>osps</key><value>1</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>taps</key><value>rrc_taps</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>freq0</key><value>center_freq+rf_freq_offset</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>10</value></param>
<param><key>args</key><value></value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate*8</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>gui_hint</key><value>1,0</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>alpha1</key><value>0.5</value></param>
<param><key>label1</key><value>RX Data</value></param>
<param><key>name</key><value>"raw samples"</value></param>
<param><key>size</key><value>2048</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0_0</value></param>
<param><key>gui_hint</key><value>1,3</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>alpha1</key><value>0.5</value></param>
<param><key>label1</key><value>Timing Recov.</value></param>
<param><key>name</key><value>"Costas Loop Output"</value></param>
<param><key>size</key><value>2048</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0_0_0</value></param>
<param><key>gui_hint</key><value>1,1</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>alpha1</key><value>0.5</value></param>
<param><key>label1</key><value>Timing Recov.</value></param>
<param><key>name</key><value>"PFB Output"</value></param>
<param><key>size</key><value>2048</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0_0_0_0</value></param>
<param><key>gui_hint</key><value>1,2</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>alpha1</key><value>0.5</value></param>
<param><key>label1</key><value>Timing Recov.</value></param>
<param><key>name</key><value>"CMA Equalizer Output"</value></param>
<param><key>size</key><value>2048</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>8096</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>5</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>center_freq+rf_freq_offset</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>31.5</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>digital_constellation_modulator_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>channels_channel_model_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_channel_model_0</source_block_id><sink_block_id>digital_pfb_clock_sync_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_channel_model_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_cma_equalizer_cc_0</source_block_id><sink_block_id>digital_costas_loop_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_cma_equalizer_cc_0</source_block_id><sink_block_id>qtgui_const_sink_x_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_constellation_modulator_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0</source_block_id><sink_block_id>qtgui_const_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_pfb_clock_sync_xxx_0</source_block_id><sink_block_id>digital_cma_equalizer_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_pfb_clock_sync_xxx_0</source_block_id><sink_block_id>qtgui_const_sink_x_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>digital_pfb_clock_sync_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
