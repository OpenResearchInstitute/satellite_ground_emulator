<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_interp</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_rate</value></param>
<param><key>value</key><value>8000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bpsk_rate</value></param>
<param><key>value</key><value>100000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>codec_rate</value></param>
<param><key>value</key><value>64000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>guard_size</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>max_deviation</value></param>
<param><key>value</key><value>5000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>num_channels</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>payload_size</value></param>
<param><key>value</key><value>64</value></param>
</block>
<block>
<key>variable_low_pass_filter_taps</key>
<param><key>id</key><value>poly_taps</value></param>
<param><key>cutoff_freq</key><value>20000</value></param>
<param><key>gain</key><value>2.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>1000</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>preamble</value></param>
<param><key>value</key><value>[ -0.70711 + 0.70711j,   0.70711 - 0.70711j,  -0.70711 + 0.70711j,   0.70711 + 0.70711j,   0.70711 - 0.70711j,   0.70711 - 0.70711j,  -0.70711 + 0.70711j,  -0.70711 + 0.70711j, -0.70711 - 0.70711j,  -0.70711 - 0.70711j,   0.70711 - 0.70711j,   0.70711 + 0.70711j,  -0.70711 + 0.70711j,   0.70711 - 0.70711j,   0.70711 - 0.70711j,  -0.70711 + 0.70711j,  -0.70711 + 0.70711j,   0.70711 + 0.70711j,   0.70711 + 0.70711j,   0.70711 + 0.70711j,  -0.70711 - 0.70711j,  -0.70711 + 0.70711j,  -0.70711 + 0.70711j,  -0.70711 - 0.70711j,  -0.70711 - 0.70711j,   0.70711 - 0.70711j,   0.70711 + 0.70711j,  -0.70711 - 0.70711j,  -0.70711 - 0.70711j,   0.70711 - 0.70711j,   0.70711 + 0.70711j,  -0.70711 - 0.70711j,   0.70711 + 0.70711j,   0.70711 + 0.70711j,   0.70711 - 0.70711j,  -0.70711 + 0.70711j,   0.70711 + 0.70711j,  -0.70711 - 0.70711j,   0.70711 - 0.70711j,   0.70711 + 0.70711j]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>preamble_size</value></param>
<param><key>value</key><value>len(preamble)</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>qpsk_constellation</value></param>
<param><key>const_points</key><value>[(sqrt(2)/2)+(sqrt(2)/2)*1j, -(sqrt(2)/2)+(sqrt(2)/2)*1j, (sqrt(2)/2)-(sqrt(2)/2)*1j, -(sqrt(2)/2)-(sqrt(2)/2)*1j]</value></param>
<param><key>type</key><value>calcdist</value></param>
<param><key>dims</key><value>1</value></param>
<param><key>rot_sym</key><value>4</value></param>
<param><key>soft_dec_lut</key><value>'auto'</value></param>
<param><key>precision</key><value>8</value></param>
<param><key>sym_map</key><value>digital.psk_4()[1]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>quadrature_rate</value></param>
<param><key>value</key><value>audio_rate*audio_interp</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>rx_channel</value></param>
<param><key>value</key><value>payload_size+guard_size</value></param>
<param><key>gui_hint</key><value>3,2,1,1</value></param>
<param><key>label0</key><value>0</value></param>
<param><key>label1</key><value>1</value></param>
<param><key>label2</key><value>2</value></param>
<param><key>label3</key><value>3</value></param>
<param><key>num_opts</key><value>4</value></param>
<param><key>option0</key><value>payload_size+guard_size</value></param>
<param><key>option1</key><value>(payload_size+guard_size)*2</value></param>
<param><key>option2</key><value>(payload_size+guard_size)*3</value></param>
<param><key>option3</key><value>0</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>type</key><value>int</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>100000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>swaths_per_superframe</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tau</value></param>
<param><key>value</key><value>75e-6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>vocoder_rate</value></param>
<param><key>value</key><value>3200.0</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>voice_gain</value></param>
<param><key>value</key><value>.5</value></param>
<param><key>gui_hint</key><value>3,3,1,1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>2</value></param>
</block>
<block>
<key>analog_nbfm_rx</key>
<param><key>id</key><value>analog_nbfm_rx_2</value></param>
<param><key>audio_rate</key><value>audio_rate</value></param>
<param><key>max_dev</key><value>max_deviation</value></param>
<param><key>quad_rate</key><value>quadrature_rate</value></param>
<param><key>tau</key><value>tau</value></param>
</block>
<block>
<key>analog_nbfm_rx</key>
<param><key>id</key><value>analog_nbfm_rx_2_0</value></param>
<param><key>audio_rate</key><value>audio_rate</value></param>
<param><key>max_dev</key><value>max_deviation</value></param>
<param><key>quad_rate</key><value>quadrature_rate</value></param>
<param><key>tau</key><value>tau</value></param>
</block>
<block>
<key>analog_nbfm_rx</key>
<param><key>id</key><value>analog_nbfm_rx_2_0_0</value></param>
<param><key>audio_rate</key><value>audio_rate</value></param>
<param><key>max_dev</key><value>max_deviation</value></param>
<param><key>quad_rate</key><value>quadrature_rate</value></param>
<param><key>tau</key><value>tau</value></param>
</block>
<block>
<key>analog_nbfm_rx</key>
<param><key>id</key><value>analog_nbfm_rx_2_1</value></param>
<param><key>audio_rate</key><value>audio_rate</value></param>
<param><key>max_dev</key><value>max_deviation</value></param>
<param><key>quad_rate</key><value>quadrature_rate</value></param>
<param><key>tau</key><value>tau</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>samp_rate</key><value>8000</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0_0_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>delay</key><value>((num_channels*(payload_size+guard_size))/2)+preamble_size-1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_float_to_short</key>
<param><key>id</key><value>blocks_float_to_short_1</value></param>
<param><key>scale</key><value>16384</value></param>
</block>
<block>
<key>blocks_float_to_short</key>
<param><key>id</key><value>blocks_float_to_short_1_0</value></param>
<param><key>scale</key><value>16384</value></param>
</block>
<block>
<key>blocks_float_to_short</key>
<param><key>id</key><value>blocks_float_to_short_1_1</value></param>
<param><key>scale</key><value>16384</value></param>
</block>
<block>
<key>blocks_float_to_short</key>
<param><key>id</key><value>blocks_float_to_short_1_2</value></param>
<param><key>scale</key><value>16384</value></param>
</block>
<block>
<key>blocks_keep_m_in_n</key>
<param><key>id</key><value>blocks_keep_m_in_n_0</value></param>
<param><key>m</key><value>num_channels*(payload_size+guard_size)/2</value></param>
<param><key>n</key><value>num_channels*(payload_size+guard_size)/2 + preamble_size</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>offset</key><value>preamble_size</value></param>
</block>
<block>
<key>blocks_keep_m_in_n</key>
<param><key>id</key><value>blocks_keep_m_in_n_1</value></param>
<param><key>m</key><value>payload_size</value></param>
<param><key>n</key><value>num_channels*(payload_size+guard_size)</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>offset</key><value>rx_channel</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>voice_gain</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>const</key><value>voice_gain</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_1</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_1_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_1_0_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_pack_k_bits_bb</key>
<param><key>id</key><value>blocks_pack_k_bits_bb_0</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>k</key><value>8</value></param>
</block>
<block>
<key>blocks_pack_k_bits_bb</key>
<param><key>id</key><value>blocks_pack_k_bits_bb_1</value></param>
<param><key>k</key><value>2</value></param>
</block>
<block>
<key>blocks_short_to_float</key>
<param><key>id</key><value>blocks_short_to_float_0</value></param>
<param><key>scale</key><value>16384</value></param>
</block>
<block>
<key>blocks_short_to_float</key>
<param><key>id</key><value>blocks_short_to_float_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>scale</key><value>16384</value></param>
</block>
<block>
<key>blocks_short_to_float</key>
<param><key>id</key><value>blocks_short_to_float_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_short_to_float</key>
<param><key>id</key><value>blocks_short_to_float_1_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_stream_mux</key>
<param><key>id</key><value>blocks_stream_mux_0</value></param>
<param><key>lengths</key><value>payload_size,guard_size</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_stream_mux</key>
<param><key>id</key><value>blocks_stream_mux_0_0</value></param>
<param><key>lengths</key><value>payload_size,guard_size</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_stream_mux</key>
<param><key>id</key><value>blocks_stream_mux_0_0_0</value></param>
<param><key>lengths</key><value>payload_size,guard_size</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_stream_mux</key>
<param><key>id</key><value>blocks_stream_mux_0_0_1</value></param>
<param><key>lengths</key><value>payload_size,guard_size</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_stream_mux</key>
<param><key>id</key><value>blocks_stream_mux_1</value></param>
<param><key>lengths</key><value>guard_size+payload_size,guard_size+payload_size,guard_size+payload_size,guard_size+payload_size</value></param>
<param><key>num_inputs</key><value>4</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_stream_mux</key>
<param><key>id</key><value>blocks_stream_mux_2</value></param>
<param><key>lengths</key><value>len(preamble),(guard_size+payload_size)*num_channels/2</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_items</key><value>64</value></param>
</block>
<block>
<key>blocks_tagged_stream_align</key>
<param><key>id</key><value>blocks_tagged_stream_align_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>lengthtagname</key><value>corr_start</value></param>
</block>
<block>
<key>blocks_unpack_k_bits_bb</key>
<param><key>id</key><value>blocks_unpack_k_bits_bb_0</value></param>
<param><key>k</key><value>2</value></param>
</block>
<block>
<key>blocks_unpack_k_bits_bb</key>
<param><key>id</key><value>blocks_unpack_k_bits_bb_2</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>k</key><value>8</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vector</key><value>[0]*guard_size</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vector</key><value>preamble</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_items</key><value>64</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_items</key><value>64</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_1</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_items</key><value>64</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_2</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_items</key><value>64</value></param>
</block>
<block>
<key>digital_chunks_to_symbols_xx</key>
<param><key>id</key><value>digital_chunks_to_symbols_xx_0</value></param>
<param><key>dimension</key><value>1</value></param>
<param><key>in_type</key><value>byte</value></param>
<param><key>out_type</key><value>complex</value></param>
<param><key>symbol_table</key><value>qpsk_constellation.points()</value></param>
</block>
<block>
<key>digital_constellation_decoder_cb</key>
<param><key>id</key><value>digital_constellation_decoder_cb_0_0</value></param>
<param><key>constellation</key><value>qpsk_constellation</value></param>
</block>
<block>
<key>digital_corr_est_cc</key>
<param><key>id</key><value>digital_corr_est_cc_0</value></param>
<param><key>sps</key><value>1</value></param>
<param><key>symbols</key><value>preamble</value></param>
<param><key>mark_delay</key><value>0</value></param>
<param><key>threshold_method</key><value>digital.corr_est_cc.THRESHOLD_ABSOLUTE</value></param>
<param><key>threshold</key><value>0.15</value></param>
</block>
<block>
<key>digital_map_bb</key>
<param><key>id</key><value>digital_map_bb_0_0</value></param>
<param><key>map</key><value>digital.psk_4()[1]</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from math import sqrt</value></param>
</block>
<block>
<key>pfb_channelizer_ccf</key>
<param><key>id</key><value>pfb_channelizer_ccf_0</value></param>
<param><key>atten</key><value>100</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>ch_map</key><value>3,0,1,2</value></param>
<param><key>nchans</key><value>4</value></param>
<param><key>osr</key><value>1.0</value></param>
<param><key>taps</key><value>poly_taps</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>gui_hint</key><value>3,0,1,1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>name</key><value>"right before constellation decoder"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0_0</value></param>
<param><key>gui_hint</key><value>4,0,1,1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>name</key><value>"right after constellation encoder"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0_0_0</value></param>
<param><key>gui_hint</key><value>5,0,1,1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>name</key><value>"right after stream mux adds preamble"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate/num_channels</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>tab@0</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>name</key><value>"Channel 0"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_0</value></param>
<param><key>bw</key><value>samp_rate/num_channels</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>tab@1</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>"red"</value></param>
<param><key>name</key><value>"Channel 1"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_0_0</value></param>
<param><key>bw</key><value>samp_rate/num_channels</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>tab@3</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>"magenta"</value></param>
<param><key>name</key><value>"Channel 3"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_1</value></param>
<param><key>bw</key><value>samp_rate/num_channels</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>tab@2</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>"green"</value></param>
<param><key>name</key><value>"Channel 2"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_1</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>name</key><value>"Received Spectrum"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_2</value></param>
<param><key>average</key><value>0.05</value></param>
<param><key>bw</key><value>(((((payload_size + guard_size)*num_channels*swaths_per_superframe)/2)+preamble_size) / ((payload_size/vocoder_rate)*swaths_per_superframe)) * 2</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>1,0,2,1</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>name</key><value>"QPSK Spectrum"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_3</value></param>
<param><key>bw</key><value>audio_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>tab2@1</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>name</key><value>"Received Analog Voice"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>float</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_histogram_sink_x</key>
<param><key>id</key><value>qtgui_histogram_sink_x_0</value></param>
<param><key>accum</key><value>True</value></param>
<param><key>autoscale</key><value>False</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>1,2,2,1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>xmax</key><value>1</value></param>
<param><key>xmin</key><value>-1</value></param>
<param><key>name</key><value>"To Rational Resampler"</value></param>
<param><key>bins</key><value>100</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>2, 3, 1, 1</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_HORIZ</value></param>
<param><key>type</key><value>float</value></param>
<param><key>name</key><value>"end of graph"</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0_1</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>4,1,1,1</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_HORIZ</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>name</key><value>"before  unpack K bits"</value></param>
<param><key>update_time</key><value>0.2</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0_1_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>5,1,1,1</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_HORIZ</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>max</key><value>4</value></param>
<param><key>min</key><value>-4</value></param>
<param><key>name</key><value>"after  pack K bits"</value></param>
<param><key>update_time</key><value>0.2</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_1_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>1,3,1,1</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_HORIZ</value></param>
<param><key>type</key><value>short</value></param>
<param><key>max</key><value>32768</value></param>
<param><key>min</key><value>-32768</value></param>
<param><key>name</key><value>"end of graph"</value></param>
</block>
<block>
<key>qtgui_time_raster_sink_x</key>
<param><key>id</key><value>qtgui_time_raster_sink_x_0</value></param>
<param><key>gui_hint</key><value>0,2,1,1</value></param>
<param><key>color1</key><value>2</value></param>
<param><key>name</key><value>"TDM Frame"</value></param>
<param><key>ncols</key><value>(guard_size+payload_size)*num_channels</value></param>
<param><key>nrows</key><value>100</value></param>
<param><key>samp_rate</key><value>codec_rate</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>qtgui_time_raster_sink_x</key>
<param><key>id</key><value>qtgui_time_raster_sink_x_0_0</value></param>
<param><key>gui_hint</key><value>0,3,1,1</value></param>
<param><key>color1</key><value>2</value></param>
<param><key>name</key><value>"Received TDM Frame"</value></param>
<param><key>ncols</key><value>(guard_size+payload_size)*num_channels</value></param>
<param><key>nrows</key><value>100</value></param>
<param><key>samp_rate</key><value>codec_rate</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>gui_hint</key><value>tab2@0</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>name</key><value>"Preamble Correlation"</value></param>
<param><key>size</key><value>256</value></param>
<param><key>srate</key><value>bpsk_rate/2</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ylabel</key><value>"Amplitude"</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>gui_hint</key><value>5,1,1,1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"Output of Vector to Stream"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>0,4,1,1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>8</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>127</value></param>
<param><key>ymin</key><value>-128</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_2_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>gui_hint</key><value>0,4,1,1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>127</value></param>
<param><key>ymin</key><value>-128</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>interp</key><value>10</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_0_0_0</value></param>
<param><key>decim</key><value>(samp_rate/num_channels)/1000</value></param>
<param><key>interp</key><value>quadrature_rate/1000</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_0_1</value></param>
<param><key>decim</key><value>(samp_rate/num_channels)/1000</value></param>
<param><key>interp</key><value>quadrature_rate/1000</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_1_0</value></param>
<param><key>decim</key><value>(samp_rate/num_channels)/1000</value></param>
<param><key>interp</key><value>quadrature_rate/1000</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_2</value></param>
<param><key>decim</key><value>(samp_rate/num_channels)/1000</value></param>
<param><key>interp</key><value>quadrature_rate/1000</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_1</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>interp</key><value>6</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_1_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>interp</key><value>6</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_1_0_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>interp</key><value>6</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>root_raised_cosine_filter</key>
<param><key>id</key><value>root_raised_cosine_filter_0</value></param>
<param><key>alpha</key><value>0.35</value></param>
<param><key>type</key><value>interp_fir_filter_ccf</value></param>
<param><key>gain</key><value>sqrt(2)</value></param>
<param><key>interp</key><value>2</value></param>
<param><key>ntaps</key><value>101</value></param>
<param><key>samp_rate</key><value>(((((payload_size + guard_size)*num_channels*swaths_per_superframe)/2)+preamble_size) / ((payload_size/vocoder_rate)*swaths_per_superframe)) * 2</value></param>
<param><key>sym_rate</key><value>((((payload_size + guard_size)*num_channels*swaths_per_superframe)/2)+preamble_size) / ((payload_size/vocoder_rate)*swaths_per_superframe)</value></param>
</block>
<block>
<key>root_raised_cosine_filter</key>
<param><key>id</key><value>root_raised_cosine_filter_1</value></param>
<param><key>alpha</key><value>0.35</value></param>
<param><key>decim</key><value>2</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>sqrt(2)</value></param>
<param><key>ntaps</key><value>101</value></param>
<param><key>samp_rate</key><value>(((((payload_size + guard_size)*num_channels*swaths_per_superframe)/2)+preamble_size) / ((payload_size/vocoder_rate)*swaths_per_superframe)) * 2</value></param>
<param><key>sym_rate</key><value>(((((payload_size + guard_size)*num_channels*swaths_per_superframe)/2)+preamble_size) / ((payload_size/vocoder_rate)*swaths_per_superframe))</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tab</value></param>
<param><key>gui_hint</key><value>0,1,1,1</value></param>
<param><key>label0</key><value>Channel 0</value></param>
<param><key>label1</key><value>Channel 1</value></param>
<param><key>label2</key><value>Channel 2</value></param>
<param><key>label3</key><value>Channel 3</value></param>
<param><key>num_tabs</key><value>4</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tab2</value></param>
<param><key>gui_hint</key><value>1,1,2,1</value></param>
<param><key>label0</key><value>Preamble Correlation</value></param>
<param><key>label1</key><value>Received Analog Voice</value></param>
<param><key>num_tabs</key><value>2</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>1280000000</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>1</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>5*(((((payload_size + guard_size)*num_channels*swaths_per_superframe)/2)+preamble_size) / ((payload_size/vocoder_rate)*swaths_per_superframe)) * 2</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>436.025e6</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>5</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>vocoder_codec2_decode_ps</key>
<param><key>id</key><value>vocoder_codec2_decode_ps_0</value></param>
<param><key>mode</key><value>codec2.MODE_3200</value></param>
</block>
<block>
<key>vocoder_codec2_decode_ps</key>
<param><key>id</key><value>vocoder_codec2_decode_ps_0_0</value></param>
<param><key>mode</key><value>codec2.MODE_3200</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>vocoder_codec2_encode_sp</key>
<param><key>id</key><value>vocoder_codec2_encode_sp_0</value></param>
<param><key>mode</key><value>codec2.MODE_3200</value></param>
</block>
<block>
<key>vocoder_codec2_encode_sp</key>
<param><key>id</key><value>vocoder_codec2_encode_sp_0_0</value></param>
<param><key>mode</key><value>codec2.MODE_3200</value></param>
</block>
<block>
<key>vocoder_codec2_encode_sp</key>
<param><key>id</key><value>vocoder_codec2_encode_sp_0_1</value></param>
<param><key>mode</key><value>codec2.MODE_3200</value></param>
</block>
<block>
<key>vocoder_codec2_encode_sp</key>
<param><key>id</key><value>vocoder_codec2_encode_sp_0_2</value></param>
<param><key>mode</key><value>codec2.MODE_3200</value></param>
</block>
<connection><source_block_id>analog_nbfm_rx_2</source_block_id><sink_block_id>blocks_float_to_short_1_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_nbfm_rx_2</source_block_id><sink_block_id>rational_resampler_xxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_nbfm_rx_2_0</source_block_id><sink_block_id>blocks_float_to_short_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_nbfm_rx_2_0_0</source_block_id><sink_block_id>blocks_float_to_short_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_nbfm_rx_2_1</source_block_id><sink_block_id>blocks_float_to_short_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>blocks_keep_m_in_n_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_short_1</source_block_id><sink_block_id>blocks_short_to_float_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_short_1</source_block_id><sink_block_id>blocks_short_to_float_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_short_1</source_block_id><sink_block_id>vocoder_codec2_encode_sp_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_short_1_0</source_block_id><sink_block_id>vocoder_codec2_encode_sp_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_short_1_1</source_block_id><sink_block_id>vocoder_codec2_encode_sp_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_short_1_2</source_block_id><sink_block_id>vocoder_codec2_encode_sp_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0</source_block_id><sink_block_id>digital_constellation_decoder_cb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_1</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>audio_sink_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>blocks_null_sink_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pack_k_bits_bb_0</source_block_id><sink_block_id>blocks_keep_m_in_n_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pack_k_bits_bb_0</source_block_id><sink_block_id>qtgui_time_raster_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pack_k_bits_bb_1</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pack_k_bits_bb_1</source_block_id><sink_block_id>qtgui_number_sink_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_short_to_float_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_short_to_float_0</source_block_id><sink_block_id>qtgui_freq_sink_x_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_short_to_float_0</source_block_id><sink_block_id>qtgui_histogram_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_short_to_float_0</source_block_id><sink_block_id>qtgui_number_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_short_to_float_0</source_block_id><sink_block_id>rational_resampler_xxx_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_short_to_float_0_0</source_block_id><sink_block_id>rational_resampler_xxx_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_short_to_float_1</source_block_id><sink_block_id>qtgui_time_sink_x_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_short_to_float_1_0</source_block_id><sink_block_id>qtgui_time_sink_x_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_mux_0</source_block_id><sink_block_id>blocks_stream_mux_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_mux_0_0</source_block_id><sink_block_id>blocks_stream_mux_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_stream_mux_0_0_0</source_block_id><sink_block_id>blocks_stream_mux_1</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_stream_mux_0_0_1</source_block_id><sink_block_id>blocks_stream_mux_1</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_stream_mux_1</source_block_id><sink_block_id>blocks_unpack_k_bits_bb_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_mux_1</source_block_id><sink_block_id>qtgui_number_sink_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_mux_1</source_block_id><sink_block_id>qtgui_time_raster_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_mux_2</source_block_id><sink_block_id>qtgui_const_sink_x_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_mux_2</source_block_id><sink_block_id>root_raised_cosine_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>vocoder_codec2_decode_ps_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_align_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_unpack_k_bits_bb_0</source_block_id><sink_block_id>blocks_pack_k_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_unpack_k_bits_bb_2</source_block_id><sink_block_id>blocks_pack_k_bits_bb_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>blocks_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>blocks_stream_mux_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>blocks_stream_mux_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>blocks_stream_mux_0_0_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_1</source_block_id><sink_block_id>blocks_stream_mux_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>blocks_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_0</source_block_id><sink_block_id>blocks_char_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_0</source_block_id><sink_block_id>blocks_stream_mux_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_1</source_block_id><sink_block_id>blocks_stream_mux_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_2</source_block_id><sink_block_id>blocks_stream_mux_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0</source_block_id><sink_block_id>blocks_stream_mux_2</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0</source_block_id><sink_block_id>qtgui_const_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_constellation_decoder_cb_0_0</source_block_id><sink_block_id>digital_map_bb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_corr_est_cc_0</source_block_id><sink_block_id>blocks_tagged_stream_align_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_corr_est_cc_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_map_bb_0_0</source_block_id><sink_block_id>blocks_unpack_k_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>rational_resampler_xxx_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>rational_resampler_xxx_0_0_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_1</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>rational_resampler_xxx_0_1_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0_0</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>rational_resampler_xxx_0_0_0_0</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_0_0_0</source_block_id><sink_block_id>analog_nbfm_rx_2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_0_1</source_block_id><sink_block_id>analog_nbfm_rx_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_1_0</source_block_id><sink_block_id>analog_nbfm_rx_2_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_2</source_block_id><sink_block_id>analog_nbfm_rx_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_1</source_block_id><sink_block_id>audio_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_1</source_block_id><sink_block_id>blocks_null_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_1_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_1_0_0</source_block_id><sink_block_id>audio_sink_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_1_0_0</source_block_id><sink_block_id>blocks_null_sink_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>root_raised_cosine_filter_0</source_block_id><sink_block_id>qtgui_freq_sink_x_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>root_raised_cosine_filter_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>root_raised_cosine_filter_0</source_block_id><sink_block_id>root_raised_cosine_filter_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>root_raised_cosine_filter_1</source_block_id><sink_block_id>digital_corr_est_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>pfb_channelizer_ccf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vocoder_codec2_decode_ps_0</source_block_id><sink_block_id>blocks_short_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vocoder_codec2_decode_ps_0</source_block_id><sink_block_id>qtgui_number_sink_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vocoder_codec2_decode_ps_0_0</source_block_id><sink_block_id>blocks_short_to_float_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vocoder_codec2_encode_sp_0</source_block_id><sink_block_id>blocks_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vocoder_codec2_encode_sp_0_0</source_block_id><sink_block_id>blocks_vector_to_stream_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vocoder_codec2_encode_sp_0_1</source_block_id><sink_block_id>blocks_vector_to_stream_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vocoder_codec2_encode_sp_0_2</source_block_id><sink_block_id>blocks_vector_to_stream_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vocoder_codec2_encode_sp_0_2</source_block_id><sink_block_id>vocoder_codec2_decode_ps_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
